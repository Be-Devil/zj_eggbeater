# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\HEADWARE;.\HEADWARE\DELAY;.\HEADWARE\Usart;.\HEADWARE\time;.\HEADWARE\massage;.\HEADWARE\key
  group Source Group 1
    ./: main.c
  group HEADWARE
    ./HEADWARE/DELAY/: delay.c
    ./HEADWARE/Usart/: Usart.c
    ./HEADWARE/massage/: massage.c
    ./HEADWARE/time/: time.c
    ./HEADWARE/key/: key.c
